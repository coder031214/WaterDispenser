# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe  --bin --output=.\Objects\test1.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\TASK\actuator_app_play;.\TASK\Get_Sensors_Data;.\TASK\lcd_app_play;.\TASK\user_app_play;.\TASK\wifi_app_play;.\HARDWARE;.\HARDWARE\IWDG;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\WIFI;.\HARDWARE\WIFI\cloud;.\MALLOC;.\FATFS\exfuns;.\FATFS\src;.\TEXT;.\HARDWARE\SDIO;.\HARDWARE\W25QXX;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_sdio.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group MALLOC
    ./MALLOC/: malloc.c
  group FATFS
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ./FATFS/src/: diskio.c ff.c
  group TEXT
    ./TEXT/: fontupd.c text.c
  group TASK
    ./TASK/Get_Sensors_Data/: Get_Sensors_DataTask.c
    ./TASK/actuator_app_play/: actuator_app_playTask.c
    ./TASK/lcd_app_play/: lcd_app_playTask.c
    ./TASK/user_app_play/: user_app_playTask.c
    ./TASK/wifi_app_play/: wifi_app_playTask.c
  group HARDWARE
    ./HARDWARE/: adc.c beep.c dht11.c gpio.c key1.c rc522.c sg90.c spi.c stmflash.c TIM3_CAP.c tim7.c usart2.c usart4.c Encoder.c Encoder.h CountSensor.c CountSensor.h MySPI.c MySPI.h W25Q64.c W25Q64.h W25Q64_Ins.h SYN6288.c SYN6288.h
    ./HARDWARE/IWDG/: iwdg.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/WIFI/: hal_timer2.c hal_uart3.c HAL_WiFiToCloud.c WiFiToCloud.c
    ./HARDWARE/SDIO/: sdio_sdcard.c
    ./HARDWARE/W25QXX/: w25qxx.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
